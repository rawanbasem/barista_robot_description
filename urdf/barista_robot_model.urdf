Commit message: Fix laser scanner ray origin height offset

File: urdf/barista_robot_model.urdf (robot description, URDF)
Before this commit: robot barista_robot, 17 links, 16 joints
Joints:
- joint laser_scan_link_joint: origin xyz=0.100 0.0 0.0775 rpy=0 0 0 -> xyz=0.100 0.0 0.1125 rpy=0 0 0
